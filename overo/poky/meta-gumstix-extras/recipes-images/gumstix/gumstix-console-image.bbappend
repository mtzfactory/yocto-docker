IMAGE_INSTALL_append = " packagegroup-qt5 kbd kbd-keymaps tzdata tzdata-europe ntp ntpdate ntp-utils ca-certificates"
