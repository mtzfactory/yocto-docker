PACKAGECONFIG_FB     = "linuxfb"
PACKAGECONFIG_X11    = ""
PACKAGECONFIG_remove = "xcb"
PACKAGECONFIG_GL     = "opengl"
PACKAGECONFIG_RENDER2D ?= "render2d"

# To use SGX GLES2 instead of software OpenGL, uncomment:
# PACKAGECONFIG_GL_overo = "gles2 linuxfb"
