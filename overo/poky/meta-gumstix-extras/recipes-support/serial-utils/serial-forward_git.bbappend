# Original git://git.freesmartphone.org is defunct; use GitHub mirror
SRC_URI = "git://github.com/freesmartphone/cornucopia.git;protocol=https"
