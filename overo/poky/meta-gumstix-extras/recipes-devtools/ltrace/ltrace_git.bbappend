# Original git://anonscm.debian.org is defunct; use Salsa (Debian GitLab).
# Pin to the upstream branch since the original SRCREV does not exist in this repo.
SRC_URI = "git://salsa.debian.org/debian/ltrace.git;protocol=https;branch=upstream"
SRCREV = "433c7fdeb95493257ae66fa8d930c485766eb401"
